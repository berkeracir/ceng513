options:
  parameters:
    author: Berker
    generate_options: qt_gui
    id: gmsk_txrx
    output_language: python
    title: GMSK Transmitter and Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 128e3
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/berker/Desktop/ceng513/files/output.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/berker/Desktop/ceng513/files/input.txt
    repeat: 'True'
    type: byte
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0'
    mu: '0'
    omega_relative_limit: '0'
    samples_per_symbol: '4'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,1
    name: '"Transmitted Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Received Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 800e3
    center_freq0: 2.4e9
    dev_addr: '"name=winslab_8"'
    dev_args: '""'
    gain0: '45'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 800e3
    center_freq0: 2.4e9
    dc_offs_enb0: '""'
    dev_addr: '"name=winslab_3"'
    dev_args: '""'
    gain0: '49'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gmsk_mod_0, '0']
- [digital_gmsk_demod_0, '0', blocks_file_sink_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gmsk_mod_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', digital_gmsk_demod_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
