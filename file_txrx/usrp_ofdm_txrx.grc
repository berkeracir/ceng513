options:
  parameters:
    author: Berker
    generate_options: qt_gui
    id: usrp_ofdm_txrx
    output_language: python
    run_options: run
    title: OFDM Transmitter and Receiver With USRPs
  states: {}

blocks:
- name: bits_per_byte
  id: variable
  parameters:
    value: '8'
  states: {}
- name: carrier_count
  id: variable
  parameters:
    value: '26'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.5e9
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: fft_len//4
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_len_key
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_modulation.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_format
  id: variable
  parameters:
    value: digital.header_format_ofdm(occupied_carriers, n_syms=1, len_key_name=packet_len_key, frame_key_name=frame_len_key, bits_per_header_sym=header_modulation.bits_per_symbol(), bits_per_payload_sym=payload_modulation.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=packet_len_key, frame_len_tag_key=frame_len_key, bits_per_header_sym=header_modulation.bits_per_symbol(), bits_per_payload_sym=payload_modulation.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_modulation
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: number_of_points
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (occupied_carriers0,)
  states: {}
- name: occupied_carriers0
  id: variable
  parameters:
    value: '[c for c in range(-carrier_count, carrier_count+1) if c not in pilot_carriers0 and c != 0]'
  states: {}
- name: packet_count
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '96'
  states: {}
- name: packet_len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, payload_modulation.base(), occupied_carriers, pilot_carriers, pilot_symbols, 1)
  states: {}
- name: payload_modulation
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: (pilot_carriers0,)
  states: {}
- name: pilot_carriers0
  id: variable
  parameters:
    value: (-21, -7, 7, 21,)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: (pilot_symbols0,)
  states: {}
- name: pilot_symbols0
  id: variable
  parameters:
    value: (1, 1, 1, -1,)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Receiver Gain (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(5e6)
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Transmitter Gain (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '0.2'
    stop: '89.8'
    value: '80'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: packet_len
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fft_len + cp_len
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/berker/Desktop/ceng513/files/received_bytes.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/berker/Desktop/ceng513/files/transmitted_bytes.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/berker/Desktop/ceng513/files/input.txt
    length: packet_len * packet_count
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: bits_per_byte
    l: payload_modulation.bits_per_symbol()
    len_tag_key: packet_len_key
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: bits_per_byte
    l: header_modulation.bits_per_symbol()
    len_tag_key: packet_len_key
  states: {}
- name: blocks_repack_bits_bb_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: payload_modulation.bits_per_symbol()
    l: bits_per_byte
    len_tag_key: packet_len_key
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Received
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len_key
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len_key
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: header_modulation.dimensionality()
    in_type: byte
    out_type: complex
    symbol_table: header_modulation.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: payload_modulation.dimensionality()
    in_type: byte
    out_type: complex
    symbol_table: payload_modulation.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_modulation.base()
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_modulation.base()
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: packet_len_key
    packed: 'True'
  states: {state: disabled}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len_key
    packed: 'True'
  states: {state: disabled}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    guard_interval: cp_len
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: frame_len_key
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: packet_len_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2,)
  states: {}
- name: digital_ofdm_chanest_vcvc_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    rolloff: rolloff
    tagname: packet_len_key
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: cp_len
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: frame_len_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: cp_len
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: frame_len_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_0
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: frame_len_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_0_0
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: frame_len_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: packet_len_key
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: cp_len
    fft_len: fft_len
    threshold: '0.9'
  states: {}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: header_format
    len_tag_key: packet_len_key
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '1'
    gui_hint: tab@2:0,0,1,1
    label1: Transmitted
    label2: Received
    name: '"Constellation"'
    nconnections: '2'
    size: number_of_points
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: number_of_points
    gui_hint: tab@0:0,0,1,1
    label1: '"Transmitted"'
    label2: '"Received"'
    name: '"Frequency"'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color2: cyan
    color3: red
    color4: magenta
    gui_hint: tab@1:0,0,1,1
    label1: Transmitted (I)
    label2: Transmitted (Q)
    label3: Received (I)
    label4: Received (Q)
    name: '"Time"'
    nconnections: '2'
    size: number_of_points
    srate: samp_rate
    type: complex
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Frequency
    label1: Time
    label2: Constellation
    num_tabs: '3'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: ''
    center_freq0: center_freq
    dev_addr: '"name=winslab_3"'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: ''
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_addr: '"name=winslab_8"'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Header Bits
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: Time Domain
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_sink_4_0
  id: virtual_sink
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Bits
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: Time Domain
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: Payload IQ
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '1']
- [analog_random_source_x_0, '0', blocks_file_sink_1, '0']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_file_sink_1, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_multiply_xx_0, '0', digital_header_payload_demux_0, '0']
- [blocks_repack_bits_bb_0, '0', virtual_sink_0_0, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_0, '0']
- [blocks_repack_bits_bb_2, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_2, '0', blocks_tag_debug_0, '0']
- [blocks_repack_bits_bb_2, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_repack_bits_bb_2, '0', digital_crc32_bb_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tag_gate_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_tag_gate_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_tag_gate_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_tag_gate_0, '0', uhd_usrp_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_1, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_constellation_decoder_cb_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_repack_bits_bb_2, '0']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_1, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_1, '0', blocks_tag_debug_0, '0']
- [digital_crc32_bb_1, '0', blocks_tagged_stream_to_pdu_0, '0']
- [digital_header_payload_demux_0, '0', virtual_sink_4, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_4_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_chanest_vcvc_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_2, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_ofdm_serializer_vcc_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0_0, '0', digital_ofdm_serializer_vcc_0_0, '0']
- [digital_ofdm_serializer_vcc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_ofdm_serializer_vcc_0_0, '0', virtual_sink_5, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0, '1']
- [digital_packet_headerparser_b_0, header_data, digital_header_payload_demux_0, header_data]
- [digital_protocol_formatter_bb_0, '0', blocks_repack_bits_bb_1, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_1, '0', digital_ofdm_chanest_vcvc_0, '0']
- [fft_vxx_1_0, '0', digital_ofdm_frame_equalizer_vcvc_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0, '1']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '1']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [virtual_source_1, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_2, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_3, '0', fft_vxx_1, '0']
- [virtual_source_3_0, '0', fft_vxx_1_0, '0']
- [virtual_source_4, '0', digital_constellation_decoder_cb_0_0, '0']

metadata:
  file_format: 1
