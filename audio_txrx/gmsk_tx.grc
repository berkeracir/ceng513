options:
  parameters:
    author: Berker
    generate_options: qt_gui
    id: gmsk_tx
    output_language: python
    title: GMSK Transmitter
  states: {}

blocks:
- name: cvsd_encoder
  id: variable
  parameters:
    value: (8, 0.5)
  states: {}
- name: gmsk_mod
  id: variable
  parameters:
    value: (2, 0.35)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Transmitter Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '80'
    value: '30'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/berker/Desktop/ceng513/audio_txrx/input.wav
    repeat: 'False'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: gmsk_mod[1]
    samples_per_symbol: gmsk_mod[0]
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: '"Transmitted Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    name: '"Input Signal"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_freq
    dev_addr: '"name=winslab_8"'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: vocoder_cvsd_encode_fb_0
  id: vocoder_cvsd_encode_fb
  parameters:
    bw: cvsd_encoder[1]
    resample: cvsd_encoder[0]
  states: {}

connections:
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', vocoder_cvsd_encode_fb_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gmsk_mod_0, '0', uhd_usrp_sink_0, '0']
- [vocoder_cvsd_encode_fb_0, '0', digital_gmsk_mod_0, '0']

metadata:
  file_format: 1
