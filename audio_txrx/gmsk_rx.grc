options:
  parameters:
    author: Berker
    generate_options: qt_gui
    id: gmsk_rx
    output_language: python
    title: GMSK Receiver
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: int(400e3)
  states: {}
- name: cvsd_decoder
  id: variable
  parameters:
    value: (8, 0.5)
  states: {}
- name: gmsk_demod
  id: variable
  parameters:
    value: (2, 0, 0, 0, 0)
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Receiver Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '80'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.3'
    widget: slider
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: gmsk_demod[4]
    gain_mu: gmsk_demod[1]
    mu: gmsk_demod[2]
    omega_relative_limit: gmsk_demod[3]
    samples_per_symbol: gmsk_demod[0]
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,1,1
    name: '"Received Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    name: '"Output Signal"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: rx_freq
    dc_offs_enb0: '""'
    dev_addr: '"name=winslab_3"'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: vocoder_cvsd_decode_bf_0
  id: vocoder_cvsd_decode_bf
  parameters:
    bw: cvsd_decoder[1]
    resample: cvsd_decoder[0]
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_gmsk_demod_0, '0', vocoder_cvsd_decode_bf_0, '0']
- [low_pass_filter_0, '0', digital_gmsk_demod_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [vocoder_cvsd_decode_bf_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
