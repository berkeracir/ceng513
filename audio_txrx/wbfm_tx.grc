options:
  parameters:
    author: Berker
    generate_options: qt_gui
    id: wbfm_tx
    output_language: python
    title: WBFM Transmitter
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: 1.0/7
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: freq
  id: variable
  parameters:
    value: input_freq * 1e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,4
    label: Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '89'
    value: '15'
    widget: slider
  states: {}
- name: input_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,4
    label: TX Frequency (MHz)
    orient: Qt.Horizontal
    start: '80'
    step: '0.1'
    stop: '130'
    value: '122'
  states: {}
- name: input_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,4
    label: Signal Input Level
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1.0'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: audio_rate * 4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: wbfm_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 3,0,3,1
    label: WBFM TX
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: wbfm_on
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: input_level
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/berker/Desktop/ceng513/audio_txrx/input.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: quad_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,5
    name: '"Signal before WBFM"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: quad_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,5
    name: '"Signal after WBFM"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,5
    name: '"Transmitted Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dev_addr: '"name=winslab_8"'
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', analog_wfm_tx_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
