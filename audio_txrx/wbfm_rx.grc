options:
  parameters:
    author: Berker
    generate_options: qt_gui
    id: wbfm_rx
    output_language: python
    title: WBFM Receiver
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: 96e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: input_freq * 1e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '76'
    value: '15'
    widget: slider
  states: {}
- name: input_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: RX Frequency (MHz)
    orient: Qt.Horizontal
    start: '80'
    step: '0.1'
    stop: '130'
    value: '103.1'
  states: {}
- name: lpf_decim
  id: variable
  parameters:
    value: '20'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: audio_samp_rate * 2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.3'
    widget: slider
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: quad_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '96000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: lpf_decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: quad_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: '"Audio Signal"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: quad_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,1
    name: '"Received Signal after WBFM"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 0,0,1,1
    name: '"Received Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '96'
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_addr: '"name=winslab_3"'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
